# Keil uVision project GasWell.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32L152VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: GasWell
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32L1XX_MD
  c misc: --c99
  c include: ..\..\Libraries\CMSIS\CM3\DeviceSupport\inc;..\..\Libraries\CMSIS\CM3\CoreSupport\inc;..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc;..\..\User\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group User
    ../../User/src/: main.c delay.c stm32l1xx_it.c usart.c dynament.c
  group StdPeriph_Driver
    ../../Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_gpio.c stm32l1xx_rcc.c stm32l1xx_adc.c stm32l1xx_usart.c stm32l1xx_exti.c stm32l1xx_dma.c
  group Startup
    ./: startup_stm32l1xx_hd.s
  group CMSIS
    ../../Libraries/CMSIS/CM3/CoreSupport/src/: core_cm3.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/src/: system_stm32l1xx.c
  group Doc
    ../: readme.txt
